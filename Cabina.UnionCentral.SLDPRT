SolidWorks part; units mm, degrees
ref_plane "Alzado" through (0, 0, 0) normal (0, 0, 1) x (1, 0, 0)
ref_plane "Planta" through (0, 0, 0) normal (0, 1, 0) x (1, 0, 0)
ref_plane "Vista lateral" through (0, 0, 0) normal (1, 0, 0) x (0, 0, -1)
sketch "Croquis1" plane through (0, 0, 0) normal (0, 0, -1) x (-1, 0, 0)
  line L1 (-39.5, 32.5) -> (39.5, 32.5)
  line L2 (-39.5, 32.5) -> (-39.5, -32.5)
  line L3 (-39.5, -32.5) -> (39.5, -32.5)
  line L4 (39.5, 32.5) -> (39.5, -32.5)
  line L7 (-24.5, 17.5) -> (24.5, 17.5)
  line L8 (-24.5, 17.5) -> (-24.5, -17.5)
  line L9 (-24.5, -17.5) -> (24.5, -17.5)
  line L10 (24.5, 17.5) -> (24.5, -17.5)
extrude "Fondo" add sketch "Croquis1" against normal blind 2 separate body
sketch "Croquis3" plane through (0, 0, 2) normal (0, 0, 1) x (1, 0, 0)
  line L1 (-39.5, 32.5) -> (39.5, 32.5)
  line L2 (-39.5, 32.5) -> (-39.5, -32.5)
  line L3 (-39.5, -32.5) -> (39.5, -32.5)
  line L4 (39.5, 32.5) -> (39.5, -32.5)
  line L6 (-37.5, 30.5) -> (-37.5, -30.5)
  line L7 (-37.5, 30.5) -> (37.5, 30.5)
  line L8 (37.5, 30.5) -> (37.5, -30.5)
  line L9 (-37.5, -30.5) -> (37.5, -30.5)
extrude "Estructura" add sketch "Croquis3" along normal blind 86
sketch "Croquis5" plane through (-39.5, 0, 0) normal (-1, 0, 0) x (0, 0, 1)
  line L0 (13.628, 25) -> (20.556, 21)
  line L1 (20.556, 21) -> (13.628, 17)
  line L2 (13.628, 17) -> (6.7, 21)
  line L3 (6.7, 21) -> (13.628, 25)
  line L4 (0, -32.5) -> (0, 32.5) construction
  line L5 (88, 32.5) -> (0, 32.5) construction
  line L6 (13.628, 11) -> (20.556, 7)
  line L7 (6.7, 7) -> (13.628, 11)
  line L8 (13.628, 3) -> (6.7, 7)
  line L9 (20.556, 7) -> (13.628, 3)
  line L10 (13.628, -3) -> (20.556, -7)
  line L11 (6.7, -7) -> (13.628, -3)
  line L12 (13.628, -11) -> (6.7, -7)
  line L13 (20.556, -7) -> (13.628, -11)
  line L14 (13.628, -17) -> (20.556, -21)
  line L15 (6.7, -21) -> (13.628, -17)
  line L16 (13.628, -25) -> (6.7, -21)
  line L17 (20.556, -21) -> (13.628, -25)
  line L18 (37.884, 25) -> (44.812, 21)
  line L19 (44.812, 21) -> (37.884, 17)
  line L20 (37.884, 17) -> (30.956, 21)
  line L21 (30.956, 21) -> (37.884, 25)
  line L22 (44.812, 7) -> (37.884, 3)
  line L23 (37.884, 11) -> (44.812, 7)
  line L24 (30.956, 7) -> (37.884, 11)
  line L25 (37.884, 3) -> (30.956, 7)
  line L26 (44.812, -7) -> (37.884, -11)
  line L27 (37.884, -3) -> (44.812, -7)
  line L28 (30.956, -7) -> (37.884, -3)
  line L29 (37.884, -11) -> (30.956, -7)
  line L30 (37.884, -17) -> (44.812, -21)
  line L31 (44.812, -21) -> (37.884, -25)
  line L32 (37.884, -25) -> (30.956, -21)
  line L33 (30.956, -21) -> (37.884, -17)
  line L34 (62.14, 25) -> (69.068, 21)
  line L35 (69.068, 21) -> (62.14, 17)
  line L36 (62.14, 17) -> (55.212, 21)
  line L37 (55.212, 21) -> (62.14, 25)
  line L38 (69.068, 7) -> (62.14, 3)
  line L39 (62.14, 11) -> (69.068, 7)
  line L40 (55.212, 7) -> (62.14, 11)
  line L41 (62.14, 3) -> (55.212, 7)
  line L42 (69.068, -7) -> (62.14, -11)
  line L43 (62.14, -3) -> (69.068, -7)
  line L44 (55.212, -7) -> (62.14, -3)
  line L45 (62.14, -11) -> (55.212, -7)
  line L46 (62.14, -17) -> (69.068, -21)
  line L47 (69.068, -21) -> (62.14, -25)
  line L48 (62.14, -25) -> (55.212, -21)
  line L49 (55.212, -21) -> (62.14, -17)
  line L66 (50.012, 18) -> (56.94, 14)
  line L67 (56.94, 14) -> (50.012, 10)
  line L68 (50.012, 10) -> (43.084, 14)
  line L69 (43.084, 14) -> (50.012, 18)
  line L70 (50.012, 4) -> (56.94, 0)
  line L71 (43.084, 0) -> (50.012, 4)
  line L72 (50.012, -4) -> (43.084, 0)
  line L73 (56.94, -14) -> (50.012, -18)
  line L74 (50.012, -10) -> (56.94, -14)
  line L75 (43.084, -14) -> (50.012, -10)
  line L76 (18.828, 14) -> (25.756, 18)
  line L77 (67.34, 14) -> (74.268, 18) construction
  line L78 (67.34, -14) -> (74.268, -10) construction
  line L79 (74.268, -18) -> (67.34, -14) construction
  line L80 (25.756, 4) -> (32.684, 0)
  line L81 (18.828, 0) -> (25.756, 4)
  line L82 (25.756, -4) -> (18.828, 0)
  line L83 (32.684, 0) -> (25.756, -4)
  line L84 (25.756, -18) -> (18.828, -14)
  line L85 (32.684, -14) -> (25.756, -18)
  line L86 (56.94, 0) -> (50.012, -4)
  line L87 (50.012, -18) -> (43.084, -14)
  line L88 (32.684, 14) -> (25.756, 10)
  line L89 (25.756, 10) -> (18.828, 14)
  line L90 (25.756, 18) -> (32.684, 14)
  line L91 (74.268, 18) -> (81.196, 14) construction
  line L92 (81.196, 14) -> (74.268, 10) construction
  line L93 (74.268, 10) -> (67.34, 14) construction
  line L94 (81.196, 0) -> (74.268, -4)
  line L95 (74.268, 4) -> (81.196, 0)
  line L96 (67.34, 0) -> (74.268, 4)
  line L97 (74.268, -4) -> (67.34, 0)
  line L98 (81.196, -14) -> (74.268, -18) construction
  line L99 (74.268, -10) -> (81.196, -14) construction
  line L100 (25.756, -10) -> (32.684, -14)
  line L101 (18.828, -14) -> (25.756, -10)
  line L102 (88, 32.5) -> (0, 32.5) construction
  line L103 (86.396, 25) -> (93.324, 21)
  line L104 (93.324, 21) -> (86.396, 17)
  line L105 (86.396, 17) -> (79.468, 21)
  line L106 (79.468, 21) -> (86.396, 25)
  line L107 (93.324, 7) -> (86.396, 3)
  line L108 (86.396, 11) -> (93.324, 7)
  line L109 (79.468, 7) -> (86.396, 11)
  line L110 (86.396, 3) -> (79.468, 7)
  line L111 (93.324, -7) -> (86.396, -11)
  line L112 (86.396, -3) -> (93.324, -7)
  line L113 (79.468, -7) -> (86.396, -3)
  line L114 (86.396, -11) -> (79.468, -7)
  line L115 (86.396, -17) -> (93.324, -21)
  line L116 (93.324, -21) -> (86.396, -25)
  line L117 (86.396, -25) -> (79.468, -21)
  line L118 (79.468, -21) -> (86.396, -17)
  dimension "D1" = 7.9998
  dimension "D2" = 7.9998
  dimension "D3" = 6.7
  dimension "D4" = 7.5
  dimension "D5" = 8
  dimension "D7" = 13.856
  dimension "D9" = 24.256
  dimension "D10" = 14.5
  dimension "D11" = 24.256
  dimension "D12" = 14
  dimension "D6" = 4
  dimension "D8" = 4
extrude "RombosHor" cut sketch "Croquis5" against normal up to surface (79 mm away)
sketch "Croquis9" plane through (0, 32.5, 0) normal (0, 1, 0) x (1, 0, 0)
  line L0 (28, -6.6872) -> (24, -13.6154)
  line L1 (28, -6.6872) -> (32, -13.6154)
  line L2 (24, -13.6154) -> (28, -20.5436)
  line L3 (32, -13.6154) -> (28, -20.5436)
  line L4 (14, -6.6872) -> (10, -13.6154)
  line L5 (14, -6.6872) -> (18, -13.6154)
  line L6 (18, -13.6154) -> (14, -20.5436)
  line L7 (10, -13.6154) -> (14, -20.5436)
  line L8 (0, -6.6872) -> (-4, -13.6154)
  line L9 (0, -6.6872) -> (4, -13.6154)
  line L10 (4, -13.6154) -> (0, -20.5436)
  line L11 (-4, -13.6154) -> (0, -20.5436)
  line L12 (-14, -6.6872) -> (-18, -13.6154)
  line L13 (-14, -6.6872) -> (-10, -13.6154)
  line L14 (-10, -13.6154) -> (-14, -20.5436)
  line L15 (-18, -13.6154) -> (-14, -20.5436)
  line L16 (-28, -6.6872) -> (-32, -13.6154)
  line L17 (-28, -6.6872) -> (-24, -13.6154)
  line L18 (-24, -13.6154) -> (-28, -20.5436)
  line L19 (-32, -13.6154) -> (-28, -20.5436)
  line L20 (14, -30.9436) -> (10, -37.8718)
  line L21 (14, -30.9436) -> (18, -37.8718)
  line L22 (18, -37.8718) -> (14, -44.8)
  line L23 (10, -37.8718) -> (14, -44.8)
  line L24 (0, -30.9436) -> (-4, -37.8718)
  line L25 (0, -30.9436) -> (4, -37.8718)
  line L26 (4, -37.8718) -> (0, -44.8)
  line L27 (-4, -37.8718) -> (0, -44.8)
  line L28 (-14, -30.9436) -> (-18, -37.8718)
  line L29 (-14, -30.9436) -> (-10, -37.8718)
  line L30 (-10, -37.8718) -> (-14, -44.8)
  line L31 (-18, -37.8718) -> (-14, -44.8)
  line L32 (-28, -30.9436) -> (-32, -37.8718)
  line L33 (-28, -30.9436) -> (-24, -37.8718)
  line L34 (-24, -37.8718) -> (-28, -44.8)
  line L35 (-32, -37.8718) -> (-28, -44.8)
  line L36 (14, -55.2) -> (10, -62.1282)
  line L37 (14, -55.2) -> (18, -62.1282)
  line L38 (18, -62.1282) -> (14, -69.0564)
  line L39 (10, -62.1282) -> (14, -69.0564)
  line L40 (0, -55.2) -> (-4, -62.1282)
  line L41 (0, -55.2) -> (4, -62.1282)
  line L42 (4, -62.1282) -> (0, -69.0564)
  line L43 (-4, -62.1282) -> (0, -69.0564)
  line L44 (-14, -55.2) -> (-18, -62.1282)
  line L45 (-14, -55.2) -> (-10, -62.1282)
  line L46 (-10, -62.1282) -> (-14, -69.0564)
  line L47 (-18, -62.1282) -> (-14, -69.0564)
  line L48 (-28, -55.2) -> (-32, -62.1282)
  line L49 (-28, -55.2) -> (-24, -62.1282)
  line L50 (-24, -62.1282) -> (-28, -69.0564)
  line L51 (-32, -62.1282) -> (-28, -69.0564)
  line L68 (28, -30.9436) -> (24, -37.8718)
  line L69 (28, -30.9436) -> (32, -37.8718)
  line L70 (32, -37.8718) -> (28, -44.8)
  line L71 (24, -37.8718) -> (28, -44.8)
  line L72 (28, -55.2) -> (24, -62.1282)
  line L73 (28, -55.2) -> (32, -62.1282)
  line L74 (32, -62.1282) -> (28, -69.0564)
  line L75 (24, -62.1282) -> (28, -69.0564)
  line L80 (28, -6.6872) -> (14, -6.6872) construction
  line L81 (28, -6.6872) -> (28, -30.9436) construction
  line L83 (39.5, -88) -> (39.5, 0) construction
  line L87 (-39.5, 0) -> (39.5, 0) construction
  line L88 (17, -50.0018) -> (21, -56.93)
  line L89 (7, -67.33) -> (11, -74.2582)
  line L90 (-7, -67.33) -> (-11, -74.2582)
  line L91 (-7, -67.33) -> (-3, -74.2582)
  line L92 (-3, -74.2582) -> (-7, -81.1864)
  line L93 (-21, -67.33) -> (-25, -74.2582) construction
  line L94 (-21, -67.33) -> (-17, -74.2582) construction
  line L95 (-25, -74.2582) -> (-21, -81.1864) construction
  line L96 (21, -67.33) -> (25, -74.2582) construction
  line L97 (25, -74.2582) -> (21, -81.1864) construction
  line L98 (17, -74.2582) -> (21, -81.1864) construction
  line L99 (7, -18.8172) -> (3, -25.7454)
  line L100 (17, -25.7454) -> (21, -32.6736)
  line L101 (21, -18.8172) -> (25, -25.7454)
  line L102 (-7, -43.0736) -> (-11, -50.0018)
  line L103 (-3, -50.0018) -> (-7, -56.93)
  line L104 (-21, -43.0736) -> (-25, -50.0018)
  line L105 (-21, -43.0736) -> (-17, -50.0018)
  line L106 (-3, -25.7454) -> (-7, -32.6736)
  line L107 (-11, -25.7454) -> (-7, -32.6736)
  line L108 (-21, -18.8172) -> (-17, -25.7454)
  line L109 (-21, -18.8172) -> (-25, -25.7454)
  line L110 (-25, -25.7454) -> (-21, -32.6736)
  line L111 (21, -43.0736) -> (17, -50.0018)
  line L112 (11, -25.7454) -> (7, -32.6736)
  line L113 (7, -18.8172) -> (11, -25.7454)
  line L114 (7, -67.33) -> (3, -74.2582)
  line L115 (11, -74.2582) -> (7, -81.1864)
  line L116 (3, -74.2582) -> (7, -81.1864)
  line L117 (-11, -74.2582) -> (-7, -81.1864)
  line L118 (-17, -74.2582) -> (-21, -81.1864) construction
  line L119 (21, -67.33) -> (17, -74.2582) construction
  line L120 (7, -43.0736) -> (3, -50.0018)
  line L121 (7, -43.0736) -> (11, -50.0018)
  line L122 (11, -50.0018) -> (7, -56.93)
  line L123 (3, -50.0018) -> (7, -56.93)
  line L124 (21, -43.0736) -> (25, -50.0018)
  line L125 (25, -50.0018) -> (21, -56.93)
  line L126 (21, -18.8172) -> (17, -25.7454)
  line L127 (-7, -43.0736) -> (-3, -50.0018)
  line L128 (-11, -50.0018) -> (-7, -56.93)
  line L129 (-17, -50.0018) -> (-21, -56.93)
  line L130 (-25, -50.0018) -> (-21, -56.93)
  line L131 (-7, -18.8172) -> (-11, -25.7454)
  line L132 (-7, -18.8172) -> (-3, -25.7454)
  line L133 (-17, -25.7454) -> (-21, -32.6736)
  line L134 (3, -25.7454) -> (7, -32.6736)
  line L135 (25, -25.7454) -> (21, -32.6736)
  line L136 (18, -86.3846) -> (14, -93.3128)
  line L137 (10, -86.3846) -> (14, -93.3128)
  line L138 (4, -86.3846) -> (0, -93.3128)
  line L139 (-4, -86.3846) -> (0, -93.3128)
  line L140 (-10, -86.3846) -> (-14, -93.3128)
  line L141 (-18, -86.3846) -> (-14, -93.3128)
  line L142 (-24, -86.3846) -> (-28, -93.3128)
  line L143 (-32, -86.3846) -> (-28, -93.3128)
  line L144 (32, -86.3846) -> (28, -93.3128)
  line L145 (24, -86.3846) -> (28, -93.3128)
  line L146 (14, -79.4564) -> (10, -86.3846)
  line L147 (14, -79.4564) -> (18, -86.3846)
  line L148 (0, -79.4564) -> (-4, -86.3846)
  line L149 (0, -79.4564) -> (4, -86.3846)
  line L150 (-14, -79.4564) -> (-18, -86.3846)
  line L151 (-14, -79.4564) -> (-10, -86.3846)
  line L152 (-28, -79.4564) -> (-32, -86.3846)
  line L153 (-28, -79.4564) -> (-24, -86.3846)
  line L154 (28, -79.4564) -> (24, -86.3846)
  line L155 (28, -79.4564) -> (32, -86.3846)
  dimension "D1" = 8
  dimension "D2" = 8
  dimension "D3" = 8
  dimension "D4" = 13.8564
  dimension "D7" = 14
  dimension "D8" = 24.2564
  dimension "D9" = 6.6872
  dimension "D10" = 7.5
  dimension "D11" = 1.2527
  dimension "D5" = 5
  dimension "D6" = 4
extrude "RombosVert" cut sketch "Croquis9" against normal up to surface (65 mm away)
sketch "Croquis8" plane through (0, 0, 2) normal (0, 0, 1) x (1, 0, 0)
  line L0 (-37.5, -30.5) -> (37.5, -30.5) construction
  line L1 (-29.5, -1) -> (-37.5, -1)
  line L2 (-29.5, -1) -> (-29.5, 1)
  line L3 (-29.5, 1) -> (-37.5, 1)
  line L4 (-37.5, -1) -> (-37.5, 1)
  line L5 (29.5, 1) -> (37.5, 1)
  line L6 (29.5, 1) -> (29.5, -1)
  line L7 (29.5, -1) -> (37.5, -1)
  line L8 (37.5, 1) -> (37.5, -1)
  dimension "D1" = 8
  dimension "D2" = 2
  dimension "D3" = 29.5
extrude "Guias" add sketch "Croquis8" along normal blind 86
sketch "Croquis10" plane through (39.5, 0, 0) normal (1, 0, 0) x (0, 0, -1)
  line L0 (-88, 32.5) -> (0, 32.5) construction
  line L1 (-12.104, -27.5) -> (-12.104, -13.5)
  line L2 (-15.104, -13.5) -> (-12.104, -13.5)
  line L3 (-15.104, -27.5) -> (-15.104, -13.5)
  line L4 (-15.104, -27.5) -> (-12.104, -27.5)
  line L5 (-88, 0) -> (0, 0) construction
  line L6 (-75.896, 27.5) -> (-75.896, 13.5)
  line L7 (-72.896, 13.5) -> (-75.896, 13.5)
  line L8 (-72.896, 27.5) -> (-72.896, 13.5)
  line L9 (0, 32.5) -> (0, -32.5) construction
  line L11 (-44, -32.5) -> (-44, 32.5) construction
  line L12 (-15.104, 27.5) -> (-12.104, 27.5)
  line L13 (-15.104, 27.5) -> (-15.104, 13.5)
  line L14 (-15.104, 13.5) -> (-12.104, 13.5)
  line L15 (-12.104, 27.5) -> (-12.104, 13.5)
  line L16 (-72.896, 27.5) -> (-75.896, 27.5)
  line L17 (-72.896, -27.5) -> (-75.896, -27.5)
  line L18 (-72.896, -27.5) -> (-72.896, -13.5)
  line L19 (-72.896, -13.5) -> (-75.896, -13.5)
  line L20 (-75.896, -27.5) -> (-75.896, -13.5)
  line L21 (-88, -32.5) -> (0, -32.5) construction
  dimension "D1" = 44
  dimension "D2" = 32.5
  dimension "D3" = 5
  dimension "D4" = 12.104
  dimension "D5" = 86
  dimension "D6" = 3
  dimension "D7" = 14
  dimension "D8" = 5
  dimension "D9" = 12.104
extrude "AncDer01" add sketch "Croquis10" along normal blind 2.5
sketch "Croquis11" plane through (42, 0, 0) normal (1, 0, 0) x (0, 0, -1)
  line L0 (-15.104, 13.5) -> (-12.104, 13.5) construction
  line L1 (0, 32.5) -> (0, -32.5) construction
  line L2 (-15.104, 27.5) -> (-15.104, 24.1478) construction
  line L3 (-17.104, 27.5) -> (-10.104, 27.5)
  line L4 (-17.104, 27.5) -> (-17.104, 13.5)
  line L5 (-44, 32.5) -> (-44, -32.5) construction
  line L6 (-12.104, 27.5) -> (-15.104, 27.5) construction
  line L7 (-10.104, -27.5) -> (-10.104, -13.5)
  line L8 (-17.104, 13.5) -> (-10.104, 13.5)
  line L9 (-17.104, -13.5) -> (-10.104, -13.5)
  line L10 (-88, 0) -> (0, 0) construction
  line L11 (-10.104, 27.5) -> (-10.104, 13.5)
  line L12 (-17.104, -27.5) -> (-17.104, -13.5)
  line L13 (-17.104, -27.5) -> (-10.104, -27.5)
  line L14 (-70.896, -27.5) -> (-77.896, -27.5)
  line L15 (-70.896, -27.5) -> (-70.896, -13.5)
  line L16 (-77.896, 27.5) -> (-77.896, 13.5)
  line L17 (-70.896, -13.5) -> (-77.896, -13.5)
  line L18 (-70.896, 13.5) -> (-77.896, 13.5)
  line L19 (-77.896, -27.5) -> (-77.896, -13.5)
  line L20 (-70.896, 27.5) -> (-70.896, 13.5)
  line L21 (-70.896, 27.5) -> (-77.896, 27.5)
  dimension "D1" = 44
  dimension "D2" = 88
  dimension "D3" = 7
  dimension "D4" = 2
  dimension "D5" = 14
extrude "AncDer02" add sketch "Croquis11" along normal blind 1.8
sketch "Croquis12" plane through (0, 32.5, 0) normal (0, 1, 0) x (1, 0, 0)
  line L1 (20.5, -9.604) -> (20.5, -7.604)
  line L2 (34.5, -7.604) -> (20.5, -7.604)
  line L3 (34.5, -9.604) -> (34.5, -7.604)
  line L4 (34.5, -9.604) -> (20.5, -9.604)
  line L5 (20.5, -19.604) -> (20.5, -17.604)
  line L6 (34.5, -17.604) -> (20.5, -17.604)
  line L7 (34.5, -19.604) -> (34.5, -17.604)
  line L8 (34.5, -19.604) -> (20.5, -19.604)
  line L10 (39.5, -44) -> (-39.5, -44) construction
  line L11 (-20.5, -78.396) -> (-20.5, -80.396)
  line L12 (-34.5, -80.396) -> (-20.5, -80.396)
  line L13 (0, -88) -> (0, 0) construction
  line L14 (-34.5, -78.396) -> (-34.5, -80.396)
  line L15 (-34.5, -78.396) -> (-20.5, -78.396)
  line L16 (-20.5, -68.396) -> (-20.5, -70.396)
  line L17 (-34.5, -70.396) -> (-20.5, -70.396)
  line L18 (-34.5, -68.396) -> (-34.5, -70.396)
  line L19 (-34.5, -68.396) -> (-20.5, -68.396)
  line L20 (34.5, -68.396) -> (20.5, -68.396)
  line L21 (-34.5, -19.604) -> (-20.5, -19.604)
  line L22 (-34.5, -19.604) -> (-34.5, -17.604)
  line L23 (-34.5, -17.604) -> (-20.5, -17.604)
  line L24 (-20.5, -19.604) -> (-20.5, -17.604)
  line L25 (-34.5, -9.604) -> (-20.5, -9.604)
  line L26 (-34.5, -9.604) -> (-34.5, -7.604)
  line L27 (-34.5, -7.604) -> (-20.5, -7.604)
  line L28 (-20.5, -9.604) -> (-20.5, -7.604)
  line L29 (34.5, -68.396) -> (34.5, -70.396)
  line L30 (34.5, -70.396) -> (20.5, -70.396)
  line L31 (20.5, -68.396) -> (20.5, -70.396)
  line L32 (34.5, -78.396) -> (20.5, -78.396)
  line L33 (34.5, -78.396) -> (34.5, -80.396)
  line L34 (34.5, -80.396) -> (20.5, -80.396)
  line L35 (20.5, -78.396) -> (20.5, -80.396)
  line L38 (-39.5, 0) -> (39.5, 0) construction
  line L39 (-39.5, -88) -> (-39.5, 0) construction
  dimension "D1" = 2
  dimension "D2" = 2
  dimension "D3" = 7.604
  dimension "D4" = 14
  dimension "D5" = 5
  dimension "D6" = 8
  dimension "D7" = 14
  dimension "D8" = 5
  dimension "D9" = 88
  dimension "D10" = 44
  dimension "D11" = 2
  dimension "D12" = 2
  dimension "D13" = 14
  dimension "D14" = 14
  dimension "D15" = 5
  dimension "D16" = 5
  dimension "D17" = 7.604
  dimension "D18" = 8
extrude "AncSup01" add sketch "Croquis12" along normal blind 3
sketch "Croquis13" plane through (0, 35.5, 0) normal (0, 1, 0) x (1, 0, 0)
  line L0 (39.5, -44) -> (-39.5, -44) construction
  line L2 (-39.5, 0) -> (39.5, 0) construction
  line L3 (-20.5, -9.604) -> (-20.5, -7.604) construction
  line L4 (-34.5, -7.604) -> (-20.5, -7.604)
  line L5 (-34.5, -7.604) -> (-34.5, -11.604)
  line L6 (-34.5, -11.604) -> (-20.5, -11.604)
  line L7 (-20.5, -7.604) -> (-20.5, -11.604)
  line L8 (-27.4575, -19.604) -> (-21.4543, -19.604) construction
  line L10 (-34.5, -19.604) -> (-20.5, -19.604)
  line L11 (0, 0) -> (0, -88) construction
  line L13 (-34.5, -19.604) -> (-34.5, -15.604)
  line L14 (-34.5, -15.604) -> (-20.5, -15.604)
  line L15 (-20.5, -19.604) -> (-20.5, -15.604)
  line L16 (-20.5, -19.604) -> (-20.5, -17.604) construction
  line L17 (20.5, -19.604) -> (20.5, -15.604)
  line L18 (34.5, -15.604) -> (20.5, -15.604)
  line L19 (34.5, -19.604) -> (34.5, -15.604)
  line L20 (34.5, -19.604) -> (20.5, -19.604)
  line L21 (20.5, -7.604) -> (20.5, -11.604)
  line L22 (34.5, -11.604) -> (20.5, -11.604)
  line L23 (34.5, -7.604) -> (34.5, -11.604)
  line L24 (34.5, -7.604) -> (20.5, -7.604)
  line L25 (34.5, -80.396) -> (20.5, -80.396)
  line L26 (34.5, -80.396) -> (34.5, -76.396)
  line L27 (34.5, -76.396) -> (20.5, -76.396)
  line L28 (20.5, -80.396) -> (20.5, -76.396)
  line L29 (34.5, -68.396) -> (20.5, -68.396)
  line L30 (34.5, -68.396) -> (34.5, -72.396)
  line L31 (34.5, -72.396) -> (20.5, -72.396)
  line L32 (20.5, -68.396) -> (20.5, -72.396)
  line L33 (-20.5, -68.396) -> (-20.5, -72.396)
  line L34 (-34.5, -72.396) -> (-20.5, -72.396)
  line L35 (-34.5, -68.396) -> (-34.5, -72.396)
  line L36 (-34.5, -68.396) -> (-20.5, -68.396)
  line L37 (-20.5, -80.396) -> (-20.5, -76.396)
  line L38 (-34.5, -76.396) -> (-20.5, -76.396)
  line L39 (-34.5, -80.396) -> (-34.5, -76.396)
  line L40 (-34.5, -80.396) -> (-20.5, -80.396)
  dimension "D1" = 44
  dimension "D2" = 88
  dimension "D3" = 4
  dimension "D4" = 4
  dimension "D5" = 14
  dimension "D6" = 14
extrude "AncSup02" add sketch "Croquis13" along normal blind 2
sketch "Croquis52" plane through (-39.5, 0, 0) normal (-1, 0, 0) x (0, 0, 1)
  line L0 (0, -32.5) -> (0, 32.5) construction
  line L1 (88, 32.5) -> (0, 32.5) construction
  line L2 (9.604, -27.5) -> (7.604, -27.5)
  line L3 (9.604, -27.5) -> (9.604, -13.5)
  line L4 (9.604, -13.5) -> (7.604, -13.5)
  line L5 (7.604, -27.5) -> (7.604, -13.5)
  line L6 (19.604, -27.5) -> (17.604, -27.5)
  line L7 (19.604, -27.5) -> (19.604, -13.5)
  line L8 (19.604, -13.5) -> (17.604, -13.5)
  line L9 (44, 32.5) -> (44, -32.5) construction
  line L10 (17.604, -27.5) -> (17.604, -13.5)
  line L11 (78.396, 27.5) -> (80.396, 27.5)
  line L12 (78.396, 27.5) -> (78.396, 13.5)
  line L13 (78.396, 13.5) -> (80.396, 13.5)
  line L14 (80.396, 27.5) -> (80.396, 13.5)
  line L15 (68.396, 27.5) -> (70.396, 27.5)
  line L16 (88, 0) -> (0, 0) construction
  line L17 (68.396, 27.5) -> (68.396, 13.5)
  line L18 (68.396, 13.5) -> (70.396, 13.5)
  line L19 (70.396, 27.5) -> (70.396, 13.5)
  line L20 (70.396, -27.5) -> (70.396, -13.5)
  line L21 (68.396, -13.5) -> (70.396, -13.5)
  line L22 (68.396, -27.5) -> (68.396, -13.5)
  line L23 (68.396, -27.5) -> (70.396, -27.5)
  line L24 (80.396, -27.5) -> (80.396, -13.5)
  line L25 (78.396, -13.5) -> (80.396, -13.5)
  line L26 (78.396, -27.5) -> (78.396, -13.5)
  line L27 (78.396, -27.5) -> (80.396, -27.5)
  line L32 (17.604, 27.5) -> (17.604, 13.5)
  line L33 (19.604, 13.5) -> (17.604, 13.5)
  line L34 (19.604, 27.5) -> (19.604, 13.5)
  line L35 (19.604, 27.5) -> (17.604, 27.5)
  line L36 (7.604, 27.5) -> (7.604, 13.5)
  line L37 (9.604, 13.5) -> (7.604, 13.5)
  line L38 (9.604, 27.5) -> (9.604, 13.5)
  line L39 (9.604, 27.5) -> (7.604, 27.5)
  dimension "D1" = 44
  dimension "D2" = 88
  dimension "D3" = 2
  dimension "D4" = 2
  dimension "D5" = 8
  dimension "D6" = 14
  dimension "D7" = 14
  dimension "D8" = 7.604
  dimension "D9" = 5
  dimension "D10" = 5
extrude "AncIzq01" add sketch "Croquis52" along normal blind 3
sketch "Croquis53" plane through (-42.5, 0, 0) normal (-1, 0, 0) x (0, 0, 1)
  line L0 (44, 32.5) -> (44, -32.5) construction
  line L1 (0, -32.5) -> (0, 32.5) construction
  line L2 (7.604, 13.5) -> (9.604, 13.5) construction
  line L3 (7.604, 27.5) -> (11.604, 27.5)
  line L4 (7.604, 27.5) -> (7.604, 13.5)
  line L5 (7.604, 13.5) -> (11.604, 13.5)
  line L6 (11.604, 27.5) -> (11.604, 13.5)
  line L7 (17.604, 13.5) -> (19.604, 13.5) construction
  line L8 (19.604, 27.5) -> (15.604, 27.5)
  line L10 (19.604, 27.5) -> (19.604, 13.5)
  line L12 (88, 0) -> (0, 0) construction
  line L13 (19.604, 13.5) -> (15.604, 13.5)
  line L14 (15.604, 27.5) -> (15.604, 13.5)
  line L15 (15.604, -27.5) -> (15.604, -13.5)
  line L16 (19.604, -13.5) -> (15.604, -13.5)
  line L17 (19.604, -27.5) -> (19.604, -13.5)
  line L18 (19.604, -27.5) -> (15.604, -27.5)
  line L19 (11.604, -27.5) -> (11.604, -13.5)
  line L20 (7.604, -13.5) -> (11.604, -13.5)
  line L21 (7.604, -27.5) -> (7.604, -13.5)
  line L22 (7.604, -27.5) -> (11.604, -27.5)
  line L23 (80.396, -27.5) -> (76.396, -27.5)
  line L24 (80.396, -27.5) -> (80.396, -13.5)
  line L25 (80.396, -13.5) -> (76.396, -13.5)
  line L26 (76.396, -27.5) -> (76.396, -13.5)
  line L27 (68.396, -27.5) -> (72.396, -27.5)
  line L28 (68.396, -27.5) -> (68.396, -13.5)
  line L29 (68.396, -13.5) -> (72.396, -13.5)
  line L30 (72.396, -27.5) -> (72.396, -13.5)
  line L31 (72.396, 27.5) -> (72.396, 13.5)
  line L32 (68.396, 13.5) -> (72.396, 13.5)
  line L33 (68.396, 27.5) -> (68.396, 13.5)
  line L34 (68.396, 27.5) -> (72.396, 27.5)
  line L35 (76.396, 27.5) -> (76.396, 13.5)
  line L36 (80.396, 13.5) -> (76.396, 13.5)
  line L37 (80.396, 27.5) -> (80.396, 13.5)
  line L38 (80.396, 27.5) -> (76.396, 27.5)
  dimension "D1" = 44
  dimension "D2" = 88
  dimension "D3" = 4
  dimension "D4" = 4
extrude "AncIzq02" add sketch "Croquis53" along normal blind 2
sketch "Croquis54" plane through (0, -32.5, 0) normal (0, -1, 0) x (1, 0, 0)
  line L0 (0, 88) -> (0, 0) construction
  line L1 (-34.5, 15.104) -> (-20.5, 15.104)
  line L2 (-34.5, 15.104) -> (-34.5, 12.104)
  line L3 (-34.5, 12.104) -> (-20.5, 12.104)
  line L4 (-20.5, 15.104) -> (-20.5, 12.104)
  line L5 (-39.5, 88) -> (39.5, 88) construction
  line L6 (-39.5, 44) -> (39.5, 44) construction
  line L7 (-39.5, 88) -> (-39.5, 0) construction
  line L8 (39.5, 88) -> (39.5, 0) construction
  line L9 (39.5, 0) -> (-39.5, 0) construction
  line L10 (20.5, 15.104) -> (20.5, 12.104)
  line L11 (34.5, 12.104) -> (20.5, 12.104)
  line L12 (34.5, 15.104) -> (34.5, 12.104)
  line L13 (34.5, 15.104) -> (20.5, 15.104)
  line L14 (34.5, 72.896) -> (20.5, 72.896)
  line L15 (34.5, 72.896) -> (34.5, 75.896)
  line L16 (34.5, 75.896) -> (20.5, 75.896)
  line L17 (20.5, 72.896) -> (20.5, 75.896)
  line L18 (-20.5, 72.896) -> (-20.5, 75.896)
  line L19 (-34.5, 75.896) -> (-20.5, 75.896)
  line L20 (-34.5, 72.896) -> (-34.5, 75.896)
  line L21 (-34.5, 72.896) -> (-20.5, 72.896)
  dimension "D1" = 3
  dimension "D2" = 14
  dimension "D3" = 5
  dimension "D4" = 12.104
extrude "AncInf01" add sketch "Croquis54" along normal blind 2.5
sketch "Croquis55" plane through (0, -35, 0) normal (0, -1, 0) x (1, 0, 0)
  line L1 (-34.5, 77.896) -> (-20.5, 77.896)
  line L2 (-34.5, 77.896) -> (-34.5, 70.896)
  line L3 (-34.5, 70.896) -> (-20.5, 70.896)
  line L4 (-20.5, 77.896) -> (-20.5, 70.896)
  line L6 (-20.5, 72.896) -> (-20.5, 75.896) construction
  line L7 (-34.5, 75.896) -> (-34.5, 72.896) construction
  line L8 (-34.5, 72.896) -> (-20.5, 72.896) construction
  line L9 (-39.5, 44) -> (39.5, 44) construction
  line L10 (-39.5, 88) -> (-39.5, 0) construction
  line L11 (39.5, 88) -> (39.5, 0) construction
  line L12 (0, 88) -> (0, 0) construction
  line L13 (-39.5, 88) -> (39.5, 88) construction
  line L14 (20.5, 77.896) -> (20.5, 70.896)
  line L15 (34.5, 70.896) -> (20.5, 70.896)
  line L16 (34.5, 77.896) -> (34.5, 70.896)
  line L17 (34.5, 77.896) -> (20.5, 77.896)
  line L18 (34.5, 10.104) -> (20.5, 10.104)
  line L19 (34.5, 10.104) -> (34.5, 17.104)
  line L20 (34.5, 17.104) -> (20.5, 17.104)
  line L21 (20.5, 10.104) -> (20.5, 17.104)
  line L22 (-20.5, 10.104) -> (-20.5, 17.104)
  line L23 (-34.5, 17.104) -> (-20.5, 17.104)
  line L24 (-34.5, 10.104) -> (-34.5, 17.104)
  line L25 (-34.5, 10.104) -> (-20.5, 10.104)
  dimension "D1" = 7
  dimension "D2" = 2
extrude "AncInf02" add sketch "Croquis55" along normal blind 1.8
sketch "Croquis61" plane through (0, 0, 0) normal (0, 0, -1) x (-1, 0, 0)
  line L1 (20.5, 32.9) -> (34.5, 32.9)
  line L2 (20.5, 32.9) -> (20.5, 37.5)
  line L3 (20.5, 37.5) -> (34.5, 37.5)
  line L4 (34.5, 32.9) -> (34.5, 37.5)
  line L5 (20.7, 33.1) -> (20.7, 37.3)
  line L6 (20.7, 37.3) -> (34.3, 37.3)
  line L7 (34.3, 33.1) -> (34.3, 37.3)
  line L8 (20.7, 33.1) -> (34.3, 33.1)
  line L9 (0, 32.5) -> (0, 17.5) construction
  line L10 (39.5, 32.5) -> (-39.5, 32.5) construction
  line L11 (24.5, 17.5) -> (-24.5, 17.5) construction
  line L12 (-20.7, 33.1) -> (-34.3, 33.1)
  line L13 (-34.3, 33.1) -> (-34.3, 37.3)
  line L14 (-20.7, 37.3) -> (-34.3, 37.3)
  line L15 (-20.7, 33.1) -> (-20.7, 37.3)
  line L16 (-34.5, 32.9) -> (-34.5, 37.5)
  line L17 (-20.5, 37.5) -> (-34.5, 37.5)
  line L18 (-20.5, 32.9) -> (-20.5, 37.5)
  line L19 (-20.5, 32.9) -> (-34.5, 32.9)
  dimension "D1" = 0.2
extrude "EspAncSup01" add sketch "Croquis61" against normal blind 7.404 separate body
ref_plane "PlanoEspAncSup01" through (0, 0, 19.804) normal (0, 0, 1) x (1, 0, 0)
sketch "Croquis57" plane through (0, 0, 19.804) normal (0, 0, 1) x (1, 0, 0)
  line L1 (34.5, 37.5) -> (20.5457, 37.5)
  line L2 (34.5, 37.5) -> (34.5, 32.9)
  line L3 (34.5, 32.9) -> (20.5457, 32.9)
  line L4 (20.5457, 37.5) -> (20.5457, 32.9)
  line L5 (34.3, 37.3) -> (34.3, 33.1)
  line L6 (34.3, 33.1) -> (20.7457, 33.1)
  line L7 (20.7457, 37.3) -> (20.7457, 33.1)
  line L8 (34.3, 37.3) -> (20.7457, 37.3)
  line L9 (0, 32.5) -> (0, 17.5) construction
  line L10 (-24.5, 17.5) -> (24.5, 17.5) construction
  line L11 (-34.3, 37.3) -> (-20.7457, 37.3)
  line L12 (-20.7457, 37.3) -> (-20.7457, 33.1)
  line L13 (-34.3, 33.1) -> (-20.7457, 33.1)
  line L14 (-34.3, 37.3) -> (-34.3, 33.1)
  line L15 (-20.5457, 37.5) -> (-20.5457, 32.9)
  line L16 (-34.5, 32.9) -> (-20.5457, 32.9)
  line L17 (-34.5, 37.5) -> (-34.5, 32.9)
  line L18 (-34.5, 37.5) -> (-20.5457, 37.5)
  dimension "D1" = 0.2
sketch "Croquis58" plane through (0, 0, 19.804) normal (0, 0, 1) x (1, 0, 0)
  line L0 (33.8, 36.8) -> (33.8, 33.6)
  line L1 (0, 32.5) -> (0, 17.5) construction
  line L2 (-33.6, 36.6) -> (-21.4457, 36.6)
  line L3 (-21.4457, 36.6) -> (-21.4457, 33.8)
  line L4 (-33.6, 33.8) -> (-21.4457, 33.8)
  line L5 (33.8, 33.6) -> (21.2457, 33.6)
  line L6 (21.2457, 36.8) -> (21.2457, 33.6)
  line L7 (33.8, 36.8) -> (21.2457, 36.8)
  line L8 (33.6, 36.6) -> (33.6, 33.8)
  line L9 (33.6, 33.8) -> (21.4457, 33.8)
  line L10 (21.4457, 36.6) -> (21.4457, 33.8)
  line L11 (33.6, 36.6) -> (21.4457, 36.6)
  line L12 (-33.6, 36.6) -> (-33.6, 33.8)
  line L13 (-33.8, 36.8) -> (-21.2457, 36.8)
  line L14 (-21.2457, 36.8) -> (-21.2457, 33.6)
  line L15 (-33.8, 33.6) -> (-21.2457, 33.6)
  line L16 (-33.8, 36.8) -> (-33.8, 33.6)
  dimension "D1" = 0.5
  dimension "D2" = 0.2
sketch "Croquis59" plane through (0, 0, 19.804) normal (0, 0, 1) x (1, 0, 0)
  line L0 (33.1, 36.1) -> (33.1, 34.3)
  line L1 (0, 32.5) -> (0, 17.5) construction
  line L2 (-32.9, 35.9) -> (-22.1457, 35.9)
  line L3 (-22.1457, 35.9) -> (-22.1457, 34.5)
  line L4 (-32.9, 34.5) -> (-22.1457, 34.5)
  line L5 (33.1, 34.3) -> (21.9457, 34.3)
  line L6 (21.9457, 36.1) -> (21.9457, 34.3)
  line L7 (33.1, 36.1) -> (21.9457, 36.1)
  line L8 (32.9, 35.9) -> (32.9, 34.5)
  line L9 (32.9, 34.5) -> (22.1457, 34.5)
  line L10 (22.1457, 35.9) -> (22.1457, 34.5)
  line L11 (32.9, 35.9) -> (22.1457, 35.9)
  line L12 (-32.9, 35.9) -> (-32.9, 34.5)
  line L13 (-33.1, 36.1) -> (-21.9457, 36.1)
  line L14 (-21.9457, 36.1) -> (-21.9457, 34.3)
  line L15 (-33.1, 34.3) -> (-21.9457, 34.3)
  line L16 (-33.1, 36.1) -> (-33.1, 34.3)
  dimension "D1" = 0.5
  dimension "D2" = 0.2
extrude "EspAncSup02" add sketch "Croquis57" along normal blind 48.392
extrude "EspAncSup03" add sketch "Croquis58" along normal blind 48.392 separate body
extrude "EspAncSup04" add sketch "Croquis59" along normal blind 48.392 separate body
ref_plane "PlanoEspAncSup02" through (0, 32.9, 0) normal (0, 1, 0) x (1, 0, 0)
sketch "Croquis64" plane through (0, 32.9, 0) normal (0, 1, 0) x (1, 0, 0)
  line L0 (-34.5, -9.604) -> (-29.684, -9.604) construction
  line L1 (-20.5, -17.204) -> (-34.5, -17.204)
  line L2 (-20.5, -17.204) -> (-20.5, -10.004)
  line L3 (-20.5, -10.004) -> (-34.5, -10.004)
  line L4 (-34.5, -17.204) -> (-34.5, -10.004)
  line L5 (-29.6972, -17.604) -> (-34.5, -17.604) construction
  line L6 (-34.5, -7.604) -> (-34.5, -9.604) construction
  line L7 (-39.5, -44) -> (39.5, -44) construction
  line L8 (-39.5, -88) -> (-39.5, 0) construction
  line L9 (39.5, -88) -> (39.5, 0) construction
  line L10 (0, 0) -> (0, -88) construction
  line L11 (39.5, -88) -> (-39.5, -88) construction
  line L12 (34.5, -17.204) -> (34.5, -10.004)
  line L13 (20.5, -10.004) -> (34.5, -10.004)
  line L14 (20.5, -17.204) -> (20.5, -10.004)
  line L15 (20.5, -17.204) -> (34.5, -17.204)
  line L16 (20.5, -70.796) -> (34.5, -70.796)
  line L17 (20.5, -70.796) -> (20.5, -77.996)
  line L18 (20.5, -77.996) -> (34.5, -77.996)
  line L19 (34.5, -70.796) -> (34.5, -77.996)
  line L20 (-34.5, -70.796) -> (-34.5, -77.996)
  line L21 (-20.5, -77.996) -> (-34.5, -77.996)
  line L22 (-20.5, -70.796) -> (-20.5, -77.996)
  line L23 (-20.5, -70.796) -> (-34.5, -70.796)
  dimension "D1" = 0.4
  dimension "D2" = 0.4
  dimension "D3" = 14
  dimension "D4" = 7.2
extrude "EspAncSup05" add sketch "Croquis64" along normal blind 2.2
sketch "Croquis66" plane through (0, 0, 17.204) normal (0, 0, 1) x (1, 0, 0)
  line L0 (-34.3, 34.9) -> (-34.3, 33.1)
  line L1 (0, 17.5) -> (0, 30.5) construction
  line L2 (-24.5, 17.5) -> (24.5, 17.5) construction
  line L3 (37.5, 30.5) -> (-37.5, 30.5) construction
  line L4 (34.3, 34.9) -> (20.7, 34.9)
  line L5 (-34.3, 33.1) -> (-20.7, 33.1)
  line L6 (-20.7, 34.9) -> (-20.7, 33.1)
  line L7 (-34.3, 34.9) -> (-20.7, 34.9)
  line L8 (20.7, 34.9) -> (20.7, 33.1)
  line L9 (34.3, 33.1) -> (20.7, 33.1)
  line L10 (34.3, 34.9) -> (34.3, 33.1)
  dimension "D1" = 0.2
extrude "EspAncSup06" cut sketch "Croquis66" against normal up to next (7.2 mm away)
sketch "Croquis68" plane through (0, 0, 77.996) normal (0, 0, 1) x (1, 0, 0)
  line L0 (34.3, 34.9) -> (34.3, 33.1)
  line L1 (0, 17.5) -> (0, 32.5) construction
  line L2 (-24.5, 17.5) -> (24.5, 17.5) construction
  line L3 (-34.3, 34.9) -> (-20.7, 34.9)
  line L4 (-20.7, 34.9) -> (-20.7, 33.1)
  line L5 (34.3, 33.1) -> (20.7, 33.1)
  line L6 (20.7, 34.9) -> (20.7, 33.1)
  line L7 (34.3, 34.9) -> (20.7, 34.9)
  line L8 (-34.3, 33.1) -> (-20.7, 33.1)
  line L9 (-34.3, 34.9) -> (-34.3, 33.1)
  dimension "D1" = 0.2
extrude "EspAncSup07" cut sketch "Croquis68" against normal up to next (7.2 mm away)
sketch "Croquis70" plane through (0, 35.5, 0) normal (0, -1, 0) x (1, 0, 0)
  line L1 (20.5, 70.396) -> (20.5, 72.396) construction
  line L2 (20.5, 72.396) -> (34.5, 72.396) construction
  line L3 (34.5, 76.396) -> (20.5, 76.396) construction
  line L4 (34.5, 72.396) -> (34.5, 70.396) construction
  line L5 (-34.5, 76.196) -> (-34.5, 72.596)
  line L6 (-20.5, 72.596) -> (-34.5, 72.596)
  line L7 (-20.5, 76.196) -> (-20.5, 72.596)
  line L8 (0, 88) -> (0, 0) construction
  line L9 (39.5, 88) -> (-39.5, 88) construction
  line L10 (39.5, 44) -> (-39.5, 44) construction
  line L11 (39.5, 88) -> (39.5, 0) construction
  line L12 (-39.5, 88) -> (-39.5, 0) construction
  line L13 (-20.5, 76.196) -> (-34.5, 76.196)
  line L14 (34.5, 11.804) -> (34.5, 15.404)
  line L15 (20.5, 15.404) -> (34.5, 15.404)
  line L16 (20.5, 11.804) -> (20.5, 15.404)
  line L17 (20.5, 76.196) -> (34.5, 76.196)
  line L18 (20.5, 76.196) -> (20.5, 72.596)
  line L19 (20.5, 72.596) -> (34.5, 72.596)
  line L20 (34.5, 76.196) -> (34.5, 72.596)
  line L21 (20.5, 11.804) -> (34.5, 11.804)
  line L22 (-20.5, 11.804) -> (-34.5, 11.804)
  line L23 (-20.5, 11.804) -> (-20.5, 15.404)
  line L24 (-20.5, 15.404) -> (-34.5, 15.404)
  line L25 (-34.5, 11.804) -> (-34.5, 15.404)
  dimension "D1" = 0.2
  dimension "D2" = 0.2
extrude "EspAncSup08" add sketch "Croquis70" against normal blind 2 separate body
sketch "Croquis71" plane through (0, 0, 72.596) normal (0, 0, -1) x (-1, 0, 0)
  line L0 (-34.3, 37.3) -> (-34.3, 35.7)
  line L2 (0, 32.5) -> (0, 17.5) construction
  line L3 (39.5, 32.5) -> (-39.5, 32.5) construction
  line L4 (24.5, 17.5) -> (-24.5, 17.5) construction
  line L5 (-20.7, 35.7) -> (-34.3, 35.7)
  line L6 (-20.7, 37.3) -> (-20.7, 35.7)
  line L7 (-20.7, 37.3) -> (-34.3, 37.3)
  line L8 (20.7, 37.3) -> (34.3, 37.3)
  line L9 (20.7, 37.3) -> (20.7, 35.7)
  line L10 (20.7, 35.7) -> (34.3, 35.7)
  line L11 (34.3, 37.3) -> (34.3, 35.7)
  dimension "D1" = 0.2
extrude "EspAncSup09" cut sketch "Croquis71" against normal up to next
sketch "Croquis72" plane through (0, 0, 11.804) normal (0, 0, -1) x (-1, 0, 0)
  line L0 (-34.3, 37.3) -> (-34.3, 35.7)
  line L1 (0, 32.5) -> (0, 17.5) construction
  line L2 (39.5, 32.5) -> (-39.5, 32.5) construction
  line L3 (24.5, 17.5) -> (-24.5, 17.5) construction
  line L4 (34.3, 37.3) -> (20.7, 37.3)
  line L5 (-34.3, 35.7) -> (-20.7, 35.7)
  line L6 (-20.7, 37.3) -> (-20.7, 35.7)
  line L7 (-34.3, 37.3) -> (-20.7, 37.3)
  line L8 (20.7, 37.3) -> (20.7, 35.7)
  line L9 (34.3, 35.7) -> (20.7, 35.7)
  line L10 (34.3, 37.3) -> (34.3, 35.7)
  dimension "D1" = 0.2
extrude "EspAncSup10" cut sketch "Croquis72" against normal up to next
sketch "Croquis73" plane through (0, 0, 0) normal (0, 0, -1) x (-1, 0, 0)
  line L1 (39.9, 27.5) -> (44.5, 27.5)
  line L2 (39.9, 27.5) -> (39.9, 13.5)
  line L3 (39.9, 13.5) -> (44.5, 13.5)
  line L4 (44.5, 27.5) -> (44.5, 13.5)
  line L6 (39.5, 0) -> (24.5, 0) construction
  line L7 (39.5, -32.5) -> (39.5, 32.5) construction
  line L8 (24.5, -17.5) -> (24.5, 17.5) construction
  line L9 (40.1, -27.3) -> (40.1, -13.7)
  line L10 (40.1, -13.7) -> (44.3, -13.7)
  line L11 (44.3, -27.3) -> (44.3, -13.7)
  line L12 (40.1, -27.3) -> (44.3, -27.3)
  line L13 (40.1, 27.3) -> (44.3, 27.3)
  line L14 (44.3, 27.3) -> (44.3, 13.7)
  line L15 (40.1, 13.7) -> (44.3, 13.7)
  line L16 (40.1, 27.3) -> (40.1, 13.7)
  line L17 (44.5, -27.5) -> (44.5, -13.5)
  line L18 (39.9, -13.5) -> (44.5, -13.5)
  line L19 (39.9, -27.5) -> (39.9, -13.5)
  line L20 (39.9, -27.5) -> (44.5, -27.5)
  dimension "D1" = 0.2
extrude "EspAncIzq01" add sketch "Croquis73" against normal blind 7.404 separate body
sketch "Croquis74" plane through (0, 0, 19.804) normal (0, 0, 1) x (1, 0, 0)
  line L1 (-39.9, 27.5) -> (-44.5, 27.5)
  line L2 (-39.9, 27.5) -> (-39.9, 13.5)
  line L3 (-39.9, 13.5) -> (-44.5, 13.5)
  line L4 (-44.5, 27.5) -> (-44.5, 13.5)
  line L5 (-40.1, 27.3) -> (-44.3, 27.3)
  line L6 (-44.3, 27.3) -> (-44.3, 13.7)
  line L7 (-40.1, 13.7) -> (-44.3, 13.7)
  line L8 (-40.1, 27.3) -> (-40.1, 13.7)
  line L9 (-39.5, 0) -> (-24.5, 0) construction
  line L10 (-39.5, 32.5) -> (-39.5, -32.5) construction
  line L11 (-24.5, -17.5) -> (-24.5, 17.5) construction
  line L12 (-40.1, -27.3) -> (-40.1, -13.7)
  line L13 (-40.1, -13.7) -> (-44.3, -13.7)
  line L14 (-44.3, -27.3) -> (-44.3, -13.7)
  line L15 (-40.1, -27.3) -> (-44.3, -27.3)
  line L16 (-44.5, -27.5) -> (-44.5, -13.5)
  line L17 (-39.9, -13.5) -> (-44.5, -13.5)
  line L18 (-39.9, -27.5) -> (-39.9, -13.5)
  line L19 (-39.9, -27.5) -> (-44.5, -27.5)
  dimension "D1" = 0.2
sketch "Croquis75" plane through (0, 0, 19.804) normal (0, 0, 1) x (1, 0, 0)
  line L0 (-40.6, 26.8) -> (-40.6, 14.2)
  line L1 (-39.5, 0) -> (-24.5, 0) construction
  line L2 (-40.8, -26.6) -> (-40.8, -14.4)
  line L3 (-40.8, -14.4) -> (-43.6, -14.4)
  line L4 (-43.6, -26.6) -> (-43.6, -14.4)
  line L5 (-40.6, 14.2) -> (-43.8, 14.2)
  line L6 (-43.8, 26.8) -> (-43.8, 14.2)
  line L7 (-40.6, 26.8) -> (-43.8, 26.8)
  line L8 (-40.8, 26.6) -> (-43.6, 26.6)
  line L9 (-43.6, 26.6) -> (-43.6, 14.4)
  line L10 (-40.8, 14.4) -> (-43.6, 14.4)
  line L11 (-40.8, 26.6) -> (-40.8, 14.4)
  line L12 (-40.8, -26.6) -> (-43.6, -26.6)
  line L13 (-40.6, -26.8) -> (-43.8, -26.8)
  line L14 (-43.8, -26.8) -> (-43.8, -14.2)
  line L15 (-40.6, -14.2) -> (-43.8, -14.2)
  line L16 (-40.6, -26.8) -> (-40.6, -14.2)
  dimension "D1" = 0.5
  dimension "D2" = 0.2
sketch "Croquis76" plane through (0, 0, 19.804) normal (0, 0, 1) x (1, 0, 0)
  line L0 (-41.3, 26.1) -> (-41.3, 14.9)
  line L1 (-39.5, 0) -> (-24.5, 0) construction
  line L2 (-41.5, -25.9) -> (-42.9, -25.9)
  line L3 (-42.9, -25.9) -> (-42.9, -15.1)
  line L4 (-41.5, -15.1) -> (-42.9, -15.1)
  line L5 (-41.3, 14.9) -> (-43.1, 14.9)
  line L6 (-43.1, 26.1) -> (-43.1, 14.9)
  line L7 (-41.3, 26.1) -> (-43.1, 26.1)
  line L8 (-41.5, 25.9) -> (-41.5, 15.1)
  line L9 (-41.5, 15.1) -> (-42.9, 15.1)
  line L10 (-42.9, 25.9) -> (-42.9, 15.1)
  line L11 (-41.5, 25.9) -> (-42.9, 25.9)
  line L12 (-41.5, -25.9) -> (-41.5, -15.1)
  line L13 (-41.3, -26.1) -> (-43.1, -26.1)
  line L14 (-43.1, -26.1) -> (-43.1, -14.9)
  line L15 (-41.3, -14.9) -> (-43.1, -14.9)
  line L16 (-41.3, -26.1) -> (-41.3, -14.9)
  dimension "D1" = 0.5
  dimension "D2" = 0.2
extrude "EspAncIzq02" add sketch "Croquis74" along normal blind 48.392 separate body
extrude "EspAncIzq03" add sketch "Croquis75" along normal blind 48.392 separate body
extrude "EspAncIzq04" add sketch "Croquis76" along normal blind 48.392 separate body
ref_plane "PlanoEspAncIzq01" through (-39.9, 0, 0) normal (-1, 0, 0) x (0, 0, 1)
sketch "Croquis77" plane through (-39.9, 0, 0) normal (-1, 0, 0) x (0, 0, 1)
  line L1 (9.804, 13.5) -> (17.404, 13.5)
  line L2 (9.804, 13.5) -> (9.804, 27.5)
  line L3 (9.804, 27.5) -> (17.404, 27.5)
  line L4 (17.404, 13.5) -> (17.404, 27.5)
  line L5 (19.604, 27.5) -> (17.604, 27.5) construction
  line L7 (7.604, 13.5) -> (9.604, 13.5) construction
  line L8 (44, 32.5) -> (44, -32.5) construction
  line L9 (88, 32.5) -> (0, 32.5) construction
  line L10 (88, -32.5) -> (0, -32.5) construction
  line L11 (88, 0) -> (0, 0) construction
  line L12 (88, 32.5) -> (88, -32.5) construction
  line L13 (0, -32.5) -> (0, 32.5) construction
  line L14 (70.596, 13.5) -> (70.596, 27.5)
  line L15 (78.196, 27.5) -> (70.596, 27.5)
  line L16 (78.196, 13.5) -> (78.196, 27.5)
  line L17 (78.196, 13.5) -> (70.596, 13.5)
  line L18 (78.196, -13.5) -> (70.596, -13.5)
  line L19 (78.196, -13.5) -> (78.196, -27.5)
  line L20 (78.196, -27.5) -> (70.596, -27.5)
  line L21 (70.596, -13.5) -> (70.596, -27.5)
  line L22 (17.404, -13.5) -> (17.404, -27.5)
  line L23 (9.804, -27.5) -> (17.404, -27.5)
  line L24 (9.804, -13.5) -> (9.804, -27.5)
  line L25 (9.804, -13.5) -> (17.404, -13.5)
  dimension "D1" = 0.2
  dimension "D2" = 0.2
extrude "EspAncIzq05" add sketch "Croquis77" along normal blind 2.2
sketch "Croquis78" plane through (0, 0, 9.804) normal (0, 0, -1) x (-1, 0, 0)
  line L0 (41.9, 13.7) -> (41.9, 27.3)
  line L1 (39.5, 0) -> (24.5, 0) construction
  line L2 (24.5, -17.5) -> (24.5, 17.5) construction
  line L3 (41.9, -13.7) -> (40.1, -13.7)
  line L4 (40.1, -13.7) -> (40.1, -27.3)
  line L5 (41.9, 27.3) -> (40.1, 27.3)
  line L6 (40.1, 13.7) -> (40.1, 27.3)
  line L7 (41.9, 13.7) -> (40.1, 13.7)
  line L8 (41.9, -27.3) -> (40.1, -27.3)
  line L9 (41.9, -13.7) -> (41.9, -27.3)
  dimension "D1" = 0.2
extrude "EspAncIzq06" cut sketch "Croquis78" against normal up to next
sketch "Croquis79" plane through (0, 0, 70.596) normal (0, 0, -1) x (-1, 0, 0)
  line L0 (40.1, 27.3) -> (40.1, 13.7)
  line L1 (39.5, 0) -> (24.5, 0) construction
  line L2 (39.5, -32.5) -> (39.5, 32.5) construction
  line L3 (24.5, -17.5) -> (24.5, 17.5) construction
  line L4 (40.1, -27.3) -> (41.9, -27.3)
  line L5 (40.1, 13.7) -> (41.9, 13.7)
  line L6 (41.9, 27.3) -> (41.9, 13.7)
  line L7 (40.1, 27.3) -> (41.9, 27.3)
  line L8 (41.9, -27.3) -> (41.9, -13.7)
  line L9 (40.1, -13.7) -> (41.9, -13.7)
  line L10 (40.1, -27.3) -> (40.1, -13.7)
  dimension "D1" = 0.2
extrude "EspAncIzq07" cut sketch "Croquis79" against normal up to next
sketch "Croquis80" plane through (-42.5, 0, 0) normal (1, 0, 0) x (0, 0, -1)
  line L1 (-15.404, -13.5) -> (-11.804, -13.5)
  line L2 (-15.404, -13.5) -> (-15.404, -27.5)
  line L3 (-15.404, -27.5) -> (-11.804, -27.5)
  line L4 (-11.804, -13.5) -> (-11.804, -27.5)
  line L5 (-11.604, -27.5) -> (-11.604, -13.5) construction
  line L6 (-9.604, -27.5) -> (-11.604, -27.5) construction
  line L8 (-17.604, -13.5) -> (-15.604, -13.5) construction
  line L9 (-15.604, -13.5) -> (-15.604, -27.5) construction
  line L10 (-44, -32.5) -> (-44, 32.5) construction
  line L11 (-88, -32.5) -> (0, -32.5) construction
  line L12 (-88, 32.5) -> (0, 32.5) construction
  line L13 (0, 0) -> (-88, 0) construction
  line L14 (-88, 32.5) -> (-88, -32.5) construction
  line L15 (-76.196, -13.5) -> (-76.196, -27.5)
  line L16 (-72.596, -27.5) -> (-76.196, -27.5)
  line L17 (-72.596, -13.5) -> (-72.596, -27.5)
  line L18 (-72.596, -13.5) -> (-76.196, -13.5)
  line L19 (-72.596, 13.5) -> (-76.196, 13.5)
  line L20 (-72.596, 13.5) -> (-72.596, 27.5)
  line L21 (-72.596, 27.5) -> (-76.196, 27.5)
  line L22 (-76.196, 13.5) -> (-76.196, 27.5)
  line L23 (-11.804, 13.5) -> (-11.804, 27.5)
  line L24 (-15.404, 27.5) -> (-11.804, 27.5)
  line L25 (-15.404, 13.5) -> (-15.404, 27.5)
  line L26 (-15.404, 13.5) -> (-11.804, 13.5)
  dimension "D1" = 0.2
  dimension "D2" = 0.2
extrude "EspAncIzq08" add sketch "Croquis80" against normal blind 2
sketch "Croquis81" plane through (0, 0, 11.804) normal (0, 0, -1) x (-1, 0, 0)
  line L0 (44.3, -27.3) -> (44.3, -13.7)
  line L1 (39.5, 0) -> (24.5, 0) construction
  line L2 (39.5, -32.5) -> (39.5, 32.5) construction
  line L3 (24.5, -17.5) -> (24.5, 17.5) construction
  line L4 (44.3, 27.3) -> (42.7, 27.3)
  line L5 (44.3, -13.7) -> (42.7, -13.7)
  line L6 (42.7, -27.3) -> (42.7, -13.7)
  line L7 (44.3, -27.3) -> (42.7, -27.3)
  line L8 (42.7, 27.3) -> (42.7, 13.7)
  line L9 (44.3, 13.7) -> (42.7, 13.7)
  line L10 (44.3, 27.3) -> (44.3, 13.7)
  dimension "D1" = 0.2
extrude "EspAncIzq09" cut sketch "Croquis81" against normal up to next
sketch "Croquis82" plane through (0, 0, 72.596) normal (0, 0, -1) x (-1, 0, 0)
  line L0 (44.3, 27.3) -> (44.3, 13.7)
  line L1 (39.5, 0) -> (24.5, 0) construction
  line L2 (39.5, -32.5) -> (39.5, 32.5) construction
  line L3 (24.5, -17.5) -> (24.5, 17.5) construction
  line L4 (44.3, -27.3) -> (42.7, -27.3)
  line L5 (44.3, 13.7) -> (42.7, 13.7)
  line L6 (42.7, 27.3) -> (42.7, 13.7)
  line L7 (44.3, 27.3) -> (42.7, 27.3)
  line L8 (42.7, -27.3) -> (42.7, -13.7)
  line L9 (44.3, -13.7) -> (42.7, -13.7)
  line L10 (44.3, -27.3) -> (44.3, -13.7)
  dimension "D1" = 0.2
extrude "EspAncIzq10" cut sketch "Croquis82" against normal up to next
sketch "Croquis83" plane through (0, 0, 0) normal (0, 0, -1) x (-1, 0, 0)
  line L1 (34.5, -32.9) -> (20.5, -32.9)
  line L2 (34.5, -32.9) -> (34.5, -34.6)
  line L3 (34.5, -34.6) -> (20.5, -34.6)
  line L4 (20.5, -32.9) -> (20.5, -34.6)
  line L8 (-39.5, -32.5) -> (39.5, -32.5) construction
  line L9 (34.3, -33.1) -> (20.7, -33.1)
  line L10 (20.7, -33.1) -> (20.7, -34.4)
  line L11 (34.3, -34.4) -> (20.7, -34.4)
  line L12 (34.3, -33.1) -> (34.3, -34.4)
  line L13 (0, -32.5) -> (0, -17.5) construction
  line L14 (-24.5, -17.5) -> (24.5, -17.5) construction
  line L15 (-34.3, -33.1) -> (-34.3, -34.4)
  line L16 (-34.3, -34.4) -> (-20.7, -34.4)
  line L17 (-20.7, -33.1) -> (-20.7, -34.4)
  line L18 (-34.3, -33.1) -> (-20.7, -33.1)
  line L19 (-20.5, -32.9) -> (-20.5, -34.6)
  line L20 (-34.5, -34.6) -> (-20.5, -34.6)
  line L21 (-34.5, -32.9) -> (-34.5, -34.6)
  line L22 (-34.5, -32.9) -> (-20.5, -32.9)
  dimension "D1" = 0.4
  dimension "D2" = 1.7
  dimension "D3" = 14
  dimension "D4" = 0.2
extrude "EspAncInf01" add sketch "Croquis83" against normal blind 11.904 separate body
sketch "Croquis85" plane through (0, 0, 0) normal (0, 0, -1) x (-1, 0, 0)
  line L0 (0, -32.5) -> (0, -17.5) construction
  line L1 (34.3, -35.2) -> (20.7, -35.2)
  line L2 (20.7, -35.2) -> (20.7, -36.6)
  line L3 (34.3, -36.6) -> (20.7, -36.6)
  line L4 (34.3, -35.2) -> (34.3, -36.6)
  line L5 (-39.5, -32.5) -> (39.5, -32.5) construction
  line L6 (-24.5, -17.5) -> (24.5, -17.5) construction
  line L7 (20.5, -35) -> (20.5, -36.8)
  line L8 (34.5, -36.8) -> (20.5, -36.8)
  line L9 (34.5, -35) -> (34.5, -36.8)
  line L10 (34.5, -35) -> (20.5, -35)
  line L11 (-34.5, -35) -> (-20.5, -35)
  line L12 (-34.5, -35) -> (-34.5, -36.8)
  line L13 (-34.5, -36.8) -> (-20.5, -36.8)
  line L14 (-20.5, -35) -> (-20.5, -36.8)
  line L15 (-34.3, -35.2) -> (-34.3, -36.6)
  line L16 (-34.3, -36.6) -> (-20.7, -36.6)
  line L17 (-20.7, -35.2) -> (-20.7, -36.6)
  line L18 (-34.3, -35.2) -> (-20.7, -35.2)
  dimension "D1" = 0.2
extrude "EspAcnInf02" add sketch "Croquis85" against normal blind 9.904
ref_plane "PlanoEspAncInf01" through (0, 0, 15.304) normal (0, 0, 1) x (1, 0, 0)
sketch "Croquis87" plane through (0, 0, 15.304) normal (0, 0, 1) x (1, 0, 0)
  line L1 (34.5, -32.9) -> (20.5, -32.9)
  line L2 (34.5, -32.9) -> (34.5, -34.6)
  line L3 (34.5, -34.6) -> (20.5, -34.6)
  line L4 (20.5, -32.9) -> (20.5, -34.6)
  line L6 (34.3, -33.1) -> (20.7, -33.1)
  line L7 (20.7, -33.1) -> (20.7, -34.4)
  line L8 (34.3, -34.4) -> (20.7, -34.4)
  line L9 (34.3, -33.1) -> (34.3, -34.4)
  line L10 (0, -32.5) -> (0, -17.5) construction
  line L11 (-39.5, -32.5) -> (39.5, -32.5) construction
  line L12 (24.5, -17.5) -> (-24.5, -17.5) construction
  line L13 (-34.3, -33.1) -> (-34.3, -34.4)
  line L14 (-34.3, -34.4) -> (-20.7, -34.4)
  line L15 (-20.7, -33.1) -> (-20.7, -34.4)
  line L16 (-34.3, -33.1) -> (-20.7, -33.1)
  line L17 (-20.5, -32.9) -> (-20.5, -34.6)
  line L18 (-34.5, -34.6) -> (-20.5, -34.6)
  line L19 (-34.5, -32.9) -> (-34.5, -34.6)
  line L20 (-34.5, -32.9) -> (-20.5, -32.9)
  dimension "D1" = 0.2
  dimension "D2" = 0.4
sketch "Croquis88" plane through (0, 0, 15.304) normal (0, 0, 1) x (1, 0, 0)
  line L0 (21.1, -33.5) -> (21.1, -34)
  line L1 (0, -32.5) -> (0, -17.5) construction
  line L2 (-39.5, -32.5) -> (39.5, -32.5) construction
  line L3 (24.5, -17.5) -> (-24.5, -17.5) construction
  line L4 (-21.1, -33.5) -> (-33.9, -33.5)
  line L5 (21.1, -34) -> (33.9, -34)
  line L6 (33.9, -33.5) -> (33.9, -34)
  line L7 (21.1, -33.5) -> (33.9, -33.5)
  line L8 (-33.9, -33.5) -> (-33.9, -34)
  line L9 (-21.1, -34) -> (-33.9, -34)
  line L10 (-21.1, -33.5) -> (-21.1, -34)
  dimension "D1" = 0.4
extrude "EspAncInf03" add sketch "Croquis87" along normal blind 57.392 separate body
extrude "EspAncInf04" add sketch "Croquis88" along normal blind 57.392 separate body
ref_plane "PlanoEspAncInf02" through (0, 0, 17.304) normal (0, 0, 1) x (1, 0, 0)
sketch "Croquis90" plane through (0, 0, 17.304) normal (0, 0, 1) x (1, 0, 0)
  line L0 (-34.3, -35.2) -> (-34.3, -36.6)
  line L1 (-34.5, -35) -> (-20.5, -35)
  line L2 (-34.5, -35) -> (-34.5, -36.8)
  line L3 (-34.5, -36.8) -> (-20.5, -36.8)
  line L4 (-20.5, -35) -> (-20.5, -36.8)
  line L5 (-34.3, -36.6) -> (-20.7, -36.6)
  line L6 (-20.7, -35.2) -> (-20.7, -36.6)
  line L7 (-34.3, -35.2) -> (-20.7, -35.2)
  line L8 (0, -32.5) -> (0, -17.5) construction
  line L9 (-39.5, -32.5) -> (39.5, -32.5) construction
  line L10 (24.5, -17.5) -> (-24.5, -17.5) construction
  line L11 (34.3, -35.2) -> (20.7, -35.2)
  line L12 (20.7, -35.2) -> (20.7, -36.6)
  line L13 (34.3, -36.6) -> (20.7, -36.6)
  line L14 (20.5, -35) -> (20.5, -36.8)
  line L15 (34.5, -36.8) -> (20.5, -36.8)
  line L16 (34.5, -35) -> (34.5, -36.8)
  line L17 (34.5, -35) -> (20.5, -35)
  line L18 (34.3, -35.2) -> (34.3, -36.6)
  dimension "D1" = 0.2
sketch "Croquis91" plane through (0, 0, 17.304) normal (0, 0, 1) x (1, 0, 0)
  line L0 (-33.9, -35.6) -> (-33.9, -36.2)
  line L1 (-33.7, -35.8) -> (-21.3, -35.8)
  line L2 (-21.3, -35.8) -> (-21.3, -36)
  line L3 (-33.7, -36) -> (-21.3, -36)
  line L4 (-33.7, -35.8) -> (-33.7, -36)
  line L5 (-33.9, -36.2) -> (-21.1, -36.2)
  line L6 (-21.1, -35.6) -> (-21.1, -36.2)
  line L7 (-33.9, -35.6) -> (-21.1, -35.6)
  line L8 (0, -32.5) -> (0, -17.5) construction
  line L9 (-39.5, -32.5) -> (39.5, -32.5) construction
  line L10 (33.9, -35.6) -> (21.1, -35.6)
  line L11 (21.1, -35.6) -> (21.1, -36.2)
  line L12 (33.9, -36.2) -> (21.1, -36.2)
  line L13 (33.7, -35.8) -> (33.7, -36)
  line L14 (33.7, -36) -> (21.3, -36)
  line L15 (21.3, -35.8) -> (21.3, -36)
  line L16 (33.7, -35.8) -> (21.3, -35.8)
  line L17 (33.9, -35.6) -> (33.9, -36.2)
  dimension "D1" = 0.2
extrude "EspAncInf05" add sketch "Croquis90" along normal blind 53.392 separate body
extrude "EspAncInf06" add sketch "Croquis91" along normal blind 53.392 separate body
sketch "Croquis93" plane through (0, 0, 0) normal (0, 0, -1) x (-1, 0, 0)
  line L1 (-39.9, -27.5) -> (-41.6, -27.5)
  line L2 (-39.9, -27.5) -> (-39.9, -13.5)
  line L3 (-39.9, -13.5) -> (-41.6, -13.5)
  line L4 (-41.6, -27.5) -> (-41.6, -13.5)
  line L6 (-40.1, -27.3) -> (-40.1, -13.7)
  line L7 (-40.1, -13.7) -> (-41.4, -13.7)
  line L8 (-41.4, -27.3) -> (-41.4, -13.7)
  line L9 (-40.1, -27.3) -> (-41.4, -27.3)
  line L10 (-24.5, 0) -> (-39.5, 0) construction
  line L12 (-24.5, 17.5) -> (-24.5, -17.5) construction
  line L13 (-40.1, 27.3) -> (-41.4, 27.3)
  line L14 (-41.4, 27.3) -> (-41.4, 13.7)
  line L15 (-40.1, 13.7) -> (-41.4, 13.7)
  line L16 (-40.1, 27.3) -> (-40.1, 13.7)
  line L17 (-41.6, 27.5) -> (-41.6, 13.5)
  line L18 (-39.9, 13.5) -> (-41.6, 13.5)
  line L19 (-39.9, 27.5) -> (-39.9, 13.5)
  line L20 (-39.9, 27.5) -> (-41.6, 27.5)
  dimension "D1" = 0.2
  dimension "D2" = 0.4
extrude "EspAncDer01" add sketch "Croquis93" against normal blind 11.904 separate body
sketch "Croquis94" plane through (0, 0, 0) normal (0, 0, -1) x (-1, 0, 0)
  line L0 (-42.2, -13.7) -> (-42.2, -27.3)
  line L1 (-42, -13.5) -> (-43.8, -13.5)
  line L2 (-42, -13.5) -> (-42, -27.5)
  line L3 (-42, -27.5) -> (-43.8, -27.5)
  line L4 (-43.8, -13.5) -> (-43.8, -27.5)
  line L5 (-42.2, -27.3) -> (-43.6, -27.3)
  line L6 (-43.6, -13.7) -> (-43.6, -27.3)
  line L7 (-42.2, -13.7) -> (-43.6, -13.7)
  line L8 (-24.5, 0) -> (-39.5, 0) construction
  line L9 (-24.5, 17.5) -> (-24.5, -17.5) construction
  line L10 (-42.2, 13.7) -> (-43.6, 13.7)
  line L11 (-43.6, 13.7) -> (-43.6, 27.3)
  line L12 (-42.2, 27.3) -> (-43.6, 27.3)
  line L13 (-43.8, 13.5) -> (-43.8, 27.5)
  line L14 (-42, 27.5) -> (-43.8, 27.5)
  line L15 (-42, 13.5) -> (-42, 27.5)
  line L16 (-42, 13.5) -> (-43.8, 13.5)
  line L17 (-42.2, 13.7) -> (-42.2, 27.3)
  dimension "D1" = 0.2
extrude "EspAncDer02" add sketch "Croquis94" against normal blind 9.904 separate body
ref_plane "PlanoEspAncDer01" through (0, 0, 15.304) normal (0, 0, 1) x (1, 0, 0)
sketch "Croquis95" plane through (0, 0, 15.304) normal (0, 0, 1) x (1, 0, 0)
  line L1 (39.9, -13.5) -> (41.6, -13.5)
  line L2 (39.9, -13.5) -> (39.9, -27.5)
  line L3 (39.9, -27.5) -> (41.6, -27.5)
  line L4 (41.6, -13.5) -> (41.6, -27.5)
  line L7 (41.4, -13.7) -> (41.4, -27.3)
  line L8 (40.1, -27.3) -> (41.4, -27.3)
  line L9 (40.1, -13.7) -> (40.1, -27.3)
  line L10 (40.1, -13.7) -> (41.4, -13.7)
  line L11 (39.5, 0) -> (24.5, 0) construction
  line L12 (39.5, -32.5) -> (39.5, 32.5) construction
  line L13 (24.5, 17.5) -> (24.5, -17.5) construction
  line L14 (40.1, 13.7) -> (41.4, 13.7)
  line L15 (40.1, 13.7) -> (40.1, 27.3)
  line L16 (40.1, 27.3) -> (41.4, 27.3)
  line L17 (41.4, 13.7) -> (41.4, 27.3)
  line L18 (41.6, 13.5) -> (41.6, 27.5)
  line L19 (39.9, 27.5) -> (41.6, 27.5)
  line L20 (39.9, 13.5) -> (39.9, 27.5)
  line L21 (39.9, 13.5) -> (41.6, 13.5)
  dimension "D1" = 0.2
  dimension "D2" = 0.4
sketch "Croquis96" plane through (0, 0, 15.304) normal (0, 0, 1) x (1, 0, 0)
  line L0 (40.5, -14.1) -> (40.5, -26.9)
  line L1 (39.5, 0) -> (24.5, 0) construction
  line L2 (39.5, -32.5) -> (39.5, 32.5) construction
  line L3 (40.5, 14.1) -> (41, 14.1)
  line L4 (41, 14.1) -> (41, 26.9)
  line L5 (40.5, -26.9) -> (41, -26.9)
  line L6 (41, -14.1) -> (41, -26.9)
  line L7 (40.5, -14.1) -> (41, -14.1)
  line L8 (40.5, 26.9) -> (41, 26.9)
  line L9 (40.5, 14.1) -> (40.5, 26.9)
  dimension "D1" = 0.4
extrude "EspAncDer03" add sketch "Croquis95" along normal blind 57.392 separate body
extrude "EspAncDer04" add sketch "Croquis96" along normal blind 57.392 separate body
ref_plane "PlanoEspAncDer02" through (0, 0, 17.304) normal (0, 0, 1) x (1, 0, 0)
sketch "Croquis97" plane through (0, 0, 17.304) normal (0, 0, 1) x (1, 0, 0)
  line L0 (43.6, 27.3) -> (43.6, 13.7)
  line L1 (43.8, 27.5) -> (42, 27.5)
  line L2 (43.8, 27.5) -> (43.8, 13.5)
  line L3 (43.8, 13.5) -> (42, 13.5)
  line L4 (42, 27.5) -> (42, 13.5)
  line L5 (43.6, 13.7) -> (42.2, 13.7)
  line L6 (42.2, 27.3) -> (42.2, 13.7)
  line L7 (43.6, 27.3) -> (42.2, 27.3)
  line L8 (39.5, 0) -> (24.5, 0) construction
  line L9 (24.5, 17.5) -> (24.5, -17.5) construction
  line L10 (43.6, -27.3) -> (42.2, -27.3)
  line L11 (42.2, -27.3) -> (42.2, -13.7)
  line L12 (43.6, -13.7) -> (42.2, -13.7)
  line L13 (42, -27.5) -> (42, -13.5)
  line L14 (43.8, -13.5) -> (42, -13.5)
  line L15 (43.8, -27.5) -> (43.8, -13.5)
  line L16 (43.8, -27.5) -> (42, -27.5)
  line L17 (43.6, -27.3) -> (43.6, -13.7)
  dimension "D1" = 0.2
sketch "Croquis98" plane through (0, 0, 17.304) normal (0, 0, 1) x (1, 0, 0)
  line L0 (42.6, 26.9) -> (43.2, 26.9)
  line L1 (39.5, 0) -> (24.5, 0) construction
  line L2 (42.6, -26.9) -> (42.6, -14.1)
  line L3 (42.6, -14.1) -> (43.2, -14.1)
  line L4 (43.2, -26.9) -> (43.2, -14.1)
  line L5 (43.2, 26.9) -> (43.2, 14.1)
  line L6 (42.6, 14.1) -> (43.2, 14.1)
  line L7 (42.6, 26.9) -> (42.6, 14.1)
  line L8 (42.6, -26.9) -> (43.2, -26.9)
  dimension "D1" = 0.4
extrude "EspAncDer05" add sketch "Croquis97" along normal blind 53.392 separate body
extrude "EspAncDer06" add sketch "Croquis98" along normal blind 53.392 separate body
